Commit message: Add files via upload

File: ur_description/urdf/arm_with_gripper.urdf (robot description, URDF)
Before this commit: robot ur10, 18 links, 17 joints
Joints:
- joint ee_fixed_joint: origin xyz=0.05 0.16 0.03 rpy=0.0 0 1.570796325 -> xyz=0.05 0.16 0.025 rpy=0.0 0 1.570796325
